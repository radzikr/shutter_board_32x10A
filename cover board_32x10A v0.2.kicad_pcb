# Repository radzikr/shutter_board_32x10A

## KiCad design cover board_32x10A v0.2.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6: 100nF; C_0603_1608Metric
C7: 100n; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32: LED; LED_0603_1608Metric
J1, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16: Screw_Terminal_01x03; PhoenixContact_GMSTBA_2,5_3-G_1x03_P7.50mm_Horizontal
J33: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
JP1, JP2, JP3, JP4, JP5, JP6, JP8, JP9, JP10: NO_Small; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP7: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R37, R38, R39, R43, R44: 4.7k; R_0603_1608Metric
R34, R35, R36, R40, R41, R42, R45, R46, R47: 10k; R_0603_1608Metric
Relay1, Relay2, Relay3, Relay4, Relay5, Relay6, Relay7, Relay8, Relay9, Relay10, Relay11, Relay12, Relay13, Relay14, Relay15, Relay16, Relay17, Relay18, Relay19, Relay20, Relay21, Relay22, Relay23, Relay24, Relay25, Relay26, Relay27, Relay28, Relay29, Relay30, Relay31, Relay32: FINDER-36.11; Relay_SPDT_Finder_36.11
U1, U2: MCP23017_SS; SSOP-28_5.3x10.2mm_P0.65mm
U3, U4, U5, U6: ULN2803A; SOIC-18W_7.5x11.6mm_P1.27mm
U7: MCP9808_SO8; SO-8_3.9x4.9mm_P1.27mm
U8: MCP9808_MSOP; MSOP-8_3x3mm_P0.65mm
j2: Screw_Terminal_01x03; PhoenixContact_GMSTBA_2,5_3-G_1x03_P7.50mm_Horizontal

Connections:
+5V: J33.3, JP7.3 (B)
+24V: J33.1, JP7.1 (A)
/close1: J1.3, Relay2.14
/close2: Relay4.14, j2.3
/close3: J3.3, Relay6.14
/close4: J4.3, Relay8.14
/close5: J5.3, Relay10.14
/close6: J6.3, Relay12.14
/close7: J7.3, Relay14.14
/close8: J8.3, Relay16.14
/close9: J9.3, Relay18.14
/close10: J10.3, Relay20.14
/close11: J11.3, Relay22.14
/close12: J12.3, Relay24.14
/close13: J13.3, Relay26.14
/close14: J14.3, Relay28.14
/close15: J15.3, Relay30.14
/close16: J16.3, Relay32.14
/com1: J1.1, Relay1.11
/com2: Relay3.11, j2.1
/com3: J3.1, Relay5.11
/com4: J4.1, Relay7.11
/com5: J5.1, Relay9.11
/com6: J6.1, Relay11.11
/com7: J7.1, Relay13.11
/com8: J8.1, Relay15.11
/com9: J9.1, Relay17.11
/com10: J10.1, Relay19.11
/com11: J11.1, Relay21.11
/com12: J12.1, Relay23.11
/com13: J13.1, Relay25.11
/com14: J14.1, Relay27.11
/com15: J15.1, Relay29.11
/com16: J16.1, Relay31.11
/copen13: J13.2, Relay25.14
/open1: J1.2, Relay1.14
/open2: Relay3.14, j2.2
/open3: J3.2, Relay5.14
/open4: J4.2, Relay7.14
/open5: J5.2, Relay9.14
/open6: J6.2, Relay11.14
/open7: J7.2, Relay13.14
/open8: J8.2, Relay15.14
/open9: J9.2, Relay17.14
/open10: J10.2, Relay19.14
/open11: J11.2, Relay21.14
/open12: J12.2, Relay23.14
/open14: J14.2, Relay27.14
/open15: J15.2, Relay29.14
/open16: J16.2, Relay31.14
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, J33.2, J33.4, J33.6, R34.2, R35.2, R36.2, R40.2, R41.2, R42.2, R45.2, R46.2, R47.2, U1.10 (VSS), U2.10 (VSS), U3.9 (GND), U4.9 (GND), U5.9 (GND), U6.9 (GND), U7.4 (GND), U8.4 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.2 (A), R6.2
unnamed: D7.2 (A), R7.2
unnamed: D8.2 (A), R8.2
unnamed: D9.2 (A), R9.2
unnamed: D10.2 (A), R10.2
unnamed: D11.2 (A), R11.2
unnamed: D12.2 (A), R12.2
unnamed: D13.2 (A), R13.2
unnamed: D14.2 (A), R14.2
unnamed: D15.2 (A), R15.2
unnamed: D16.2 (A), R16.2
unnamed: D17.2 (A), R17.2
unnamed: D18.2 (A), R18.2
unnamed: D19.2 (A), R19.2
unnamed: D20.2 (A), R20.2
unnamed: D21.2 (A), R21.2
unnamed: D22.2 (A), R22.2
unnamed: D23.2 (A), R23.2
unnamed: D24.2 (A), R24.2
unnamed: D25.2 (A), R25.2
unnamed: D26.2 (A), R26.2
unnamed: D27.2 (A), R27.2
unnamed: D28.2 (A), R28.2
unnamed: D29.2 (A), R29.2
unnamed: D30.2 (A), R30.2
unnamed: D31.2 (A), R31.2
unnamed: D32.2 (A), R32.2
unnamed: JP1.2, R34.1, U1.17 (A2)
unnamed: JP2.2, R35.1, U1.16 (A1)
unnamed: JP3.2, R36.1, U1.15 (A0)
unnamed: JP4.2, R40.1, U2.17 (A2)
unnamed: JP5.2, R41.1, U2.16 (A1)
unnamed: JP6.2, R42.1, U2.15 (A0)
unnamed: JP8.2, R45.1, U7.7 (A0), U8.7 (A0)
unnamed: JP9.2, R46.1, U7.6 (A1), U8.6 (A1)
unnamed: JP10.2, R47.1, U7.5 (A2), U8.5 (A2)
unnamed: R33.1, U1.18 (~RESET)
unnamed: R39.1, U2.18 (~RESET)
unnamed: R43.2, U7.3 (Alert)
unnamed: R44.2, U8.3 (Alert)
unnamed: Relay1.12, Relay2.11
unnamed: Relay3.12, Relay4.11
unnamed: Relay5.12, Relay6.11
unnamed: Relay7.12, Relay8.11
unnamed: Relay9.12, Relay10.11
unnamed: Relay11.12, Relay12.11
unnamed: Relay13.12, Relay14.11
unnamed: Relay15.12, Relay16.11
unnamed: Relay17.12, Relay18.11
unnamed: Relay19.12, Relay20.11
unnamed: Relay21.12, Relay22.11
unnamed: Relay23.12, Relay24.11
unnamed: Relay25.12, Relay26.11
unnamed: Relay27.12, Relay28.11
unnamed: Relay29.12, Relay30.11
unnamed: Relay31.12, Relay32.11
unnamed: U1.1 (GPB0), U3.1 (I1)
unnamed: U1.2 (GPB1), U3.2 (I2)
unnamed: U1.3 (GPB2), U3.3 (I3)
unnamed: U1.4 (GPB3), U3.4 (I4)
unnamed: U1.5 (GPB4), U3.5 (I5)
unnamed: U1.6 (GPB5), U3.6 (I6)
unnamed: U1.7 (GPB6), U3.7 (I7)
unnamed: U1.8 (GPB7), U3.8 (I8)
unnamed: U1.21 (GPA0), U4.1 (I1)
unnamed: U1.22 (GPA1), U4.2 (I2)
unnamed: U1.23 (GPA2), U4.3 (I3)
unnamed: U1.24 (GPA3), U4.4 (I4)
unnamed: U1.25 (GPA4), U4.5 (I5)
unnamed: U1.26 (GPA5), U4.6 (I6)
unnamed: U1.27 (GPA6), U4.7 (I7)
unnamed: U1.28 (GPA7), U4.8 (I8)
unnamed: U2.1 (GPB0), U5.1 (I1)
unnamed: U2.2 (GPB1), U5.2 (I2)
unnamed: U2.3 (GPB2), U5.3 (I3)
unnamed: U2.4 (GPB3), U5.4 (I4)
unnamed: U2.5 (GPB4), U5.5 (I5)
unnamed: U2.6 (GPB5), U5.6 (I6)
unnamed: U2.7 (GPB6), U5.7 (I7)
unnamed: U2.8 (GPB7), U5.8 (I8)
unnamed: U2.21 (GPA0), U6.1 (I1)
unnamed: U2.22 (GPA1), U6.2 (I2)
unnamed: U2.23 (GPA2), U6.3 (I3)
unnamed: U2.24 (GPA3), U6.4 (I4)
unnamed: U2.25 (GPA4), U6.5 (I5)
unnamed: U2.26 (GPA5), U6.6 (I6)
unnamed: U2.27 (GPA6), U6.7 (I7)
unnamed: U2.28 (GPA7), U6.8 (I8)
RELAY1: D1.1 (K), Relay1.A1, U6.18 (O1)
RELAY2: D2.1 (K), Relay2.A1, U6.17 (O2)
RELAY3: D3.1 (K), Relay3.A1, U6.16 (O3)
RELAY4: D4.1 (K), Relay4.A1, U6.15 (O4)
RELAY5: D5.1 (K), Relay5.A1, U6.14 (O5)
RELAY6: D6.1 (K), Relay6.A1, U6.13 (O6)
RELAY7: D7.1 (K), Relay7.A1, U6.12 (O7)
RELAY8: D8.1 (K), Relay8.A1, U6.11 (O8)
RELAY9: D9.1 (K), Relay9.A1, U5.18 (O1)
RELAY10: D10.1 (K), Relay10.A1, U5.17 (O2)
RELAY11: D11.1 (K), Relay11.A1, U5.16 (O3)
RELAY12: D12.1 (K), Relay12.A1, U5.15 (O4)
RELAY13: D13.1 (K), Relay13.A1, U5.14 (O5)
RELAY14: D14.1 (K), Relay14.A1, U5.13 (O6)
RELAY15: D15.1 (K), Relay15.A1, U5.12 (O7)
RELAY16: D16.1 (K), Relay16.A1, U5.11 (O8)
RELAY17: D17.1 (K), Relay17.A1, U4.18 (O1)
RELAY18: D18.1 (K), Relay18.A1, U4.17 (O2)
RELAY19: D19.1 (K), Relay19.A1, U4.16 (O3)
RELAY20: D20.1 (K), Relay20.A1, U4.15 (O4)
RELAY21: D21.1 (K), Relay21.A1, U4.14 (O5)
RELAY22: D22.1 (K), Relay22.A1, U4.13 (O6)
RELAY23: D23.1 (K), Relay23.A1, U4.12 (O7)
RELAY24: D24.1 (K), Relay24.A1, U4.11 (O8)
RELAY25: D25.1 (K), Relay25.A1, U3.18 (O1)
RELAY26: D26.1 (K), Relay26.A1, U3.17 (O2)
RELAY27: D27.1 (K), Relay27.A1, U3.16 (O3)
RELAY28: D28.1 (K), Relay28.A1, U3.15 (O4)
RELAY29: D29.1 (K), Relay29.A1, U3.14 (O5)
RELAY30: D30.1 (K), Relay30.A1, U3.13 (O6)
RELAY31: D31.1 (K), Relay31.A1, U3.12 (O7)
RELAY32: D32.1 (K), Relay32.A1, U3.11 (O8)
SCL: J33.7, R37.1, U1.12 (SCK), U2.12 (SCK), U7.2 (SCL), U8.2 (SCL)
SDA: J33.8, R38.1, U1.13 (SDA), U2.13 (SDA), U7.1 (SDA), U8.1 (SDA)
VCC: C2.2, C3.2, C5.2, C6.2, JP7.2 (C), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, Relay1.A2, Relay2.A2, Relay3.A2, Relay4.A2, Relay5.A2, Relay6.A2, Relay7.A2, Relay8.A2, Relay9.A2, Relay10.A2, Relay11.A2, Relay12.A2, Relay13.A2, Relay14.A2, Relay15.A2, Relay16.A2, Relay17.A2, Relay18.A2, Relay19.A2, Relay20.A2, Relay21.A2, Relay22.A2, Relay23.A2, Relay24.A2, Relay25.A2, Relay26.A2, Relay27.A2, Relay28.A2, Relay29.A2, Relay30.A2, Relay31.A2, Relay32.A2, U3.10 (COM), U4.10 (COM), U5.10 (COM), U6.10 (COM)

Notes on the sheet:
ADDRESS 0x48
HF3FF RELAY
ADDRESS 0x20
MCP23017
ADDRESS 0x21
MCP9808
MCP23017 and ULN2803A
- roller shutters board 32x10A v0.2
PINOUT

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
Board: 2 copper layers, 197.0 x 102.0 mm, 153 parts (9 on the bottom side), 180 nets.

## Commit log

2022-03-03 Add files via upload
    cover board_32x10A v0.2
